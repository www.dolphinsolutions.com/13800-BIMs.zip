Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-02-16T15:36:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Feb 16 15:36:26 2017* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{E4326419-783D-46C9-A131-CD92B77516DB}\ifc* Database version: 5507* Database creation date: Thu Feb 16 15:36:25 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Feb 16 15:36:25 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Feb 16 15:36:25 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: SatinStainlessSteel, NBS_FCFrostLtd_ToiletBrushHolders_ToiletCleaningBrushAndHolder:SatinStainlessSteel:304844
In: Level 0
Type - ElementType: SatinStainlessSteel; Classification: Pr_40_20_76_86 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FCFrostLtd_ToiletBrushHolders_ToiletCleaningBrushAndHolder_SatinStainlessSteel; ManufacturerName: FC Frost Ltd; ManufacturerURL: www.fcfrost.com; NBSCertification: www.nationalbimlibrary.com/cert/52e4ddhn; NBSDescription: Toilet brush holders; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/364; NBSTypeID: n/a; ProductInformation: www.fcfrost.com/13.1800.html; Revision: n/a; Uniclass2015Code: Pr_40_20_76_86; Uniclass2015Title: Toilet brush holders; Uniclass2015Version: Products v1.5; Version: 1
Type - NBS_Data - EnvironmentalProductDeclaration: n/a; Form: Wall mounted; IntegralAccessories: n/a; NetWeight: 1.3 kg; Spares: Contact FC Frost for spares requirements: service@fcfrost.com
Type - Pset_FurnitureTypeCommon - Description: Surface mounted, brushed finish stainless steel toilet brush holder; Style: n/a; NominalHeight: 466 mm; NominalDepth: 110 mm; MainColor: n/a
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Toilet brush holders:Pr_40_20_76_86; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Wall mounted toilet brush holder. Brushed satin stainless steel finish with acrylic lid; Finish: Satin; Grade: n/a; Manufacturer: info@fcfrost.com; Material: 1.5 mm stainless steel grade 1.4401 (316); ModelNumber: 13.1800; ModelReference: Toilet Cleaning Brush & Holder; Name: ToiletBrushHolders_ToiletCleaningBrushAndHolder_SatinStainlessSteel_FCFrostLtd; NominalWidth: 76 mm; Shape: n/a; Size: 76 x 110 x 466 mm; SustainabilityPerformance: n/a; WarrantyDescription: This product is covered by a 12 month warranty from the date of purchase to be free from defects if installed and maintained in accordance with the products instructions. FC Frost will replace or repair (as appropriate) free of charge any product with a proven manufacturing defect if reported within the warranty period; WarrantyDurationLabor: n/a; WarrantyDurationParts: year; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyGuarantorParts: sales@fcfrost.com
